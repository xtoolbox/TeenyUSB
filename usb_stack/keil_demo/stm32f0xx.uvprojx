# Keil uVision project stm32f0xx.uvprojx, settings and files
target bulk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072VBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0xx_bulk +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072
  c include: ..\inc;..\descriptor_demo;..\Drivers\STM32F0xx_HAL_Driver\Inc;..\Drivers\CMSIS\Device\ST\STM32F0xx\Include;..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group teeny_usb_stack
    ../src/: teeny_usb.c teeny_usb_stm32_fs_device.c
  group stm32f0xx
    ../src/: stm32f0_init.c
    ../demo_apps/: startup_stm32f072.s system_stm32f0xx.c
  group app
    ../demo_apps/: cdc_class.c cdc_main.c cdc7_main.c hid_class.c hid_main.c bulk_main.c
target cdc (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072VBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: stm32f0xx_cdc
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target cdc7 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072VBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: stm32f0xx_cdc7
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
target hid (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072VBHx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: as above
  output: stm32f0xx_hid
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.0.1
