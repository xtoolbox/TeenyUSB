# Keil uVision project stm32f723E_Disco.uvprojx, settings and files
target bulk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: stm32f767 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Drivers/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../descriptor_demo;../Drivers/Middlewares/ST/STM32_USB_Host_Library/Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group teeny_usb_stack
    ../src/: teeny_usb.c teeny_usb_stm32_otg_device.c teeny_usb_stm32_otg_host.c teeny_usb_host.c
  group stm32f76x
    ../src/: stm32f7_init.c
    ../demo_apps/: startup_stm32f723xx.s system_stm32f7xx_HSE25MHz.c
  group app
    ../demo_apps/: bulk_main.c cdc_class.c cdc_main.c cdc7_main.c hid_class.c hid_main.c iso_main.c host_main.c
target cdc (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: stm32f767 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Drivers/Middlewares/ST/STM32_USB_Device_Library/Class/HID/Inc;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;../descriptor_demo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
target cdc7 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: stm32f767 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
target hid (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: stm32f767 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
target iso (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: stm32f767 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
target host (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: as above
  output: stm32f767 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HOST_ONLY,HSE_VALUE=25000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.1
