# Keil uVision project rndis.uvprojx, settings and files
target stm32f407_evk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,HSE_VALUE=8000000,NO_HOST
  c include: ..\..\core;.;..\boards\stm32f407_evk;..\..\driver_stm32;..\..\mcu_lib\st_driver\STM32F4xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F4xx\Include;..\..\class\user;..\..\class\cdc;..\..\class\msc;..\..\class\hid;..\..\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group teeny_usb_stack
    ../../core/: teeny_usb_device.c teeny_usb_retarget.c
  group app
    ./: teeny_usb_desc.c rndis.c rndis_desc.lua
  group usb_device
    ../../class/: tusbd.c
    ../../class/cdc/: tusbd_cdc_rndis.c
  group stm32f407_evk
    ../boards/stm32f407_evk/: system_stm32f4xx.c startup_stm32f407xx.s board.c
    ../../mcu_lib/st_driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group stm32f767zi_nucleo
    ../boards/stm32f767zi_nucleo/: board.c system_stm32f7xx.c startup_stm32f767xx.s f767rndis_eth_init.c
    ../../mcu_lib/st_driver/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c
  group usb_driver
    ../../driver_stm32/: tusb_dev_drv_stm32_fs.c tusb_dev_drv_stm32_otg.c tusb_drv_stm32_otg_common.c
  group stm32f723_disco
    ../boards/stm32f723e_disco/: board.c system_stm32f7xx_HSE25MHz.c startup_stm32f723xx.s
    ../../mcu_lib/st_driver/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c
target stm32f767zi_nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: f767
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,HSE_VALUE=8000000,NO_HOST
  c include: ..\..\core;.;..\boards\stm32f767zi_nucleo;..\..\driver_stm32;..\..\mcu_lib\st_driver\STM32F7xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F7xx\Include;..\..\class\user;..\..\class\cdc;..\..\class\msc;..\..\class\hid;..\..\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
target stm32f723_disco (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000,NO_HOST
  c include: ..\..\core;.;..\boards\stm32f723e_disco;..\..\driver_stm32;..\..\mcu_lib\st_driver\STM32F7xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F7xx\Include;..\..\class\user;..\..\class\cdc;..\..\class\msc;..\..\class\hid;..\..\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.0.1
