# Keil uVision project rndis.uvprojx, settings and files
target stm32f072 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: f723_dap +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB,HSE_VALUE=8000000,NO_HOST,MSC_DATA_PACKET_LENGTH=2048
  c include: ..\..\usb_stack\inc;.;..\..\usb_stack\Drivers\STM32F0xx_HAL_Driver\Inc;..\..\usb_stack\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\boards\stm32f072c8t6;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group teeny_usb_stack
    ../../usb_stack/src/: stm32_otg_init.c teeny_usb.c teeny_usb_stm32_fs_device.c teeny_usb_stm32_otg_device.c stm32_fs_init.c
  group app
    ./: teeny_usb_desc.c rndis.c rndis_desc.lua
  group usb_device
    ../../usb_stack/class/: tusbd.c tusbd_cdc.c tusbd_hid.c tusbd_msc.c tusbd_user.c tusbd_cdc_rndis.c
  group stm32f072
    ../boards/stm32f072c8t6/: board.c system_stm32f0xx.c startup_stm32f072.s
  group stm32f103
    ../boards/stm32f103ret6/: system_stm32f10x.c startup_stm32f103xe.s board.c
  group stm32f3_disco
    ../boards/stm32f3_disco/: system_stm32f3xx.c board.c startup_stm32f303xc.s
  group stm32f407_evk
    ../boards/stm32f407_evk/: system_stm32f4xx.c startup_stm32f407xx.s
  group stm32f723e_disco
    ../boards/stm32f723e_disco/: startup_stm32f723xx.s system_stm32f7xx_HSE25MHz.c
  group stm32f767zi_nucleo
    ../boards/stm32f767zi_nucleo/: board.c system_stm32f7xx.c startup_stm32f767xx.s
    ../../mcu_lib/st_driver/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c
target stm32f103 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: f723_dap +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,HSE_VALUE=8000000,NO_HOST,MSC_DATA_PACKET_LENGTH=2048
  c include: ..\..\usb_stack\inc;.;..\..\usb_stack\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\usb_stack\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\boards\stm32f103ret6;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
target stm32f3_disco (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,HSE_VALUE=8000000,NO_HOST,MSC_DATA_PACKET_LENGTH=2048
  c include: ..\..\usb_stack\inc;.;..\..\usb_stack\Drivers\STM32F3xx_HAL_Driver\Inc;..\..\usb_stack\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\usb_stack\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f3_disco;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
target stm32f407_evk (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,HSE_VALUE=8000000,NO_HOST
  c include: ..\..\usb_stack\inc;.;..\..\usb_stack\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\usb_stack\Drivers\CMSIS\Device\ST\STM32F4x\Include;..\boards\stm32f407_evk;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target stm32f723e_disco (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000,NO_HOST
  c include: ..\..\usb_stack\inc;.;..\..\usb_stack\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\usb_stack\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\usb_stack\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f723e_disco;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
target stm32f767zi_nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,HSE_VALUE=8000000,NO_HOST
  c include: ..\..\usb_stack\inc;.;..\..\usb_stack\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\usb_stack\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\usb_stack\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f767zi_nucleo;..\..\usb_stack\class
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 5.0.1
