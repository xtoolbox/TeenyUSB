# Keil uVision project f723_dap.uvprojx, settings and files
target stm32f723e_disco (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: f723_dap
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F723xx,HSE_VALUE=25000000,NO_HOST
  c include: ..\..\usb_stack\inc;.;..\..\mcu_lib\st_driver\STM32F7xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F7xx\Include;..\..\mcu_lib\st_driver\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\boards\stm32f723e_disco;..\cmsis-dap
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group teeny_usb_stack
    ../../usb_stack/src/: stm32_otg_init.c teeny_usb.c teeny_usb_stm32_otg_device.c
  group app
    ./: teeny_usb_desc.c f723_dap.c cmsis_dap_desc.lua hid_class.c
  group stm32f723e_disco
    ../boards/stm32f723e_disco/: startup_stm32f723xx.s system_stm32f7xx_HSE25MHz.c
  group dap
    ../cmsis-dap/: DAP.c DAP_queue.c JTAG_DP.c SW_DP.c SWO.c
software components: CMSIS:CORE 5.0.1
