# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32f7xx (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F723IEKx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x30000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x80000) IROM2(0x00200000,0x80000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_ARM_LIBC, USE_HAL_DRIVER, USE_RTTHREAD, STM32F723xx, HSE_VALUE=25000000
  c include: .;..\..\..\rt-thread\include;.;..\boards\stm32f723e_disco;..\..\mcu_lib\st_driver\STM32F7xx_HAL_Driver\Inc;..\..\mcu_lib\st_driver\CMSIS\Device\ST\STM32F7xx\Include;..\..\mcu_lib\st_driver\CMSIS\Include;..\..\usb_stack\inc;..\..\usb_stack\class;..\..\usb_stack\class\host;applications;.;drivers;..\..\..\rt-thread\libcpu\arm\common;..\..\..\rt-thread\libcpu\arm\cortex-m7;..\..\..\rt-thread\components\dfs\include;..\..\..\rt-thread\components\dfs\filesystems\devfs;..\..\..\rt-thread\components\dfs\filesystems\elmfat;..\..\..\rt-thread\components\dfs\filesystems\ramfs;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\drivers\include;..\..\..\rt-thread\components\finsh;..\..\..\rt-thread\components\libc\compilers\armlibc;..\..\..\rt-thread\components\libc\compilers\common;..\..\..\rt-thread\components\net\lwip-2.0.2\src;..\..\..\rt-thread\components\net\lwip-2.0.2\src\include;..\..\..\rt-thread\components\net\lwip-2.0.2\src\include\ipv4;..\..\..\rt-thread\components\net\lwip-2.0.2\src\arch\include;..\..\..\rt-thread\components\net\lwip-2.0.2\src\include\netif;..\..\..\rt-thread\components\net\lwip-2.0.2\src\include\posix
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x30000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Kernel
    ../../../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Board
    ./: teeny_usb_desc.c
    ../boards/stm32f723e_disco/: system_stm32f7xx_HSE25MHz.c board.c startup_stm32f723xx.s
  group TeenyUSB
    ../../usb_stack/src/: stm32_fs_init.c stm32_otg_init.c teeny_usb.c teeny_usb_stm32_fs_device.c teeny_usb_stm32_otg_device.c teeny_usb_stm32_otg_host.c
    ../../usb_stack/class/: tusbd.c tusbd_cdc.c tusbd_cdc_rndis.c tusbd_hid.c tusbd_msc.c tusbd_user.c
    ../../usb_stack/class/host/: tusbh.c tusbh_cdc_acm.c tusbh_cdc_rndis.c tusbh_hid.c tusbh_hub.c tusbh_msc.c tusbh_no_os.c tusbh_vendor.c
  group Applications
    applications/: main.c tusb_device_app.c tusb_host_app.c tusb_rtt_os.c virtual_net.c
  group Drivers
    drivers/: bsp.c drv_usart.c
  group cpu
    ../../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../rt-thread/libcpu/arm/cortex-m7/: cpu_cache.c cpuport.c context_rvds.S
  group Filesystem
    ../../../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../../../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../rt-thread/components/dfs/filesystems/elmfat/option/: ccsbcs.c
    ../../../rt-thread/components/dfs/filesystems/ramfs/: dfs_ramfs.c
  group DeviceDrivers
    ../../../rt-thread/components/drivers/misc/: pin.c
    ../../../rt-thread/components/drivers/serial/: serial.c
    ../../../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../rt-thread/components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../../rt-thread/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../rt-thread/components/libc/compilers/common/: time.c
  group lwIP
    ../../../rt-thread/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../../rt-thread/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../rt-thread/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../rt-thread/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../rt-thread/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../rt-thread/components/net/lwip-2.0.2/src/apps/ping/: ping.c
